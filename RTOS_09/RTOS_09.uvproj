# Keil uVision project RTOS_09.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: RTOS_09 +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./: heap_1.c list.c main.c port.c queue.c system_LPC17xx.c tasks.c timers.c uart.c startup_LPC17xx.s
  group Header
    ./: croutine.h FreeRTOS.h FreeRTOSConfig.h list.h mpu_wrappers.h portable.h portmacro.h projdefs.h queue.h semphr.h StackMacros.h stdutils.h task.h timers.h uart.h
